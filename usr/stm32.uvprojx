# Keil uVision project stm32.uvprojx, settings and files
target stm32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: stm32
  c flags: Optim=4 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\core;..\hardware;..\lib\inc;..\usr
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group core
    ../core/: startup_stm32f0xx.s
  group lib
    ../lib/src/: stm32f0xx_adc.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_gpio.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c stm32f0xx_flash.c stm32f0xx_syscfg.c stm32f0xx_spi.c
  group usr
    ./: main.c stm32f0xx_it.c system_stm32f0xx.c
  group hardware
    ../hardware/: adc.c delay.c timer.c usart.c wdog.c ds18b20.c exti.c spi_max31865.c gpio.c
